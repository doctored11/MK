# Keil uVision project hello.uvproj, settings and files
target hello (5060960::V5.06 update 7 (build 960)::D:\Programs\keil\ARM\ARM_Compiler_5.06u7)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: hello
  AfterMake: fromelf --bin --output .\rvmdk\hello.bin .\rvmdk\hello.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..;..\..\..\..;C:\ti\TivaWare_C_Series-2.2.0.295\examples\boards\ek-tm4c123gxl\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: hello.sct
  link misc: --entry Reset_Handler
  group Source
    ./: hello.c startup_rvmdk.S
    ../../../../utils/: uartstdio.c
    ../drivers/: buttons.c rgb.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
